<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KasinoGroup#07.ewp</path>
    </project>
    <batchBuild />
</workspace>
